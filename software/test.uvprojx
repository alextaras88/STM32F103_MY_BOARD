# Keil uVision project test.uvprojx, settings and files
target STM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\test;.\CMSIS\inc;.\CODE\inc;.\SSD1306
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/src/: system_stm32f10x.c core_cm3.c
  group CODE
    ./CODE/src/: main.c Start_init.c Usart.c PWM.c Delay.c SPI.c max6675.c timer.c ad7799.c i2c.c mcp4725.c ads1110.c Zephyr_hafuht.c htu21d.c mlx90614.c weight.c ad7730.c ads1220.c ENCODER.c
    ./SSD1306/: ssd1306.c ssd1306_fonts.c
  group Startup
    ./Startup/: startup_stm32f10x_md_vl.s
